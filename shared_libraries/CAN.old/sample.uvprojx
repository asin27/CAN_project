# Keil uVision project sample.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: sample
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: DEBUG
  c include: ..\CanProva1;.\CAN\Drivers\include;.\CAN\headers;.\Core\Include;.\security;.\Core\CM3\CoreSupport\;.\PRNG\adc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group startup_file
    ./: startup_LPC17xx.s
  group main
    ./: main.c
  group lib_SoC_board
    ./: core_cm3.c system_LPC17xx.c
  group GLCD
    ./GLCD/: AsciiLib.c AsciiLib.h GLCD.c GLCD.h
  group Can
    ./CAN/: can.c highcan.c IRQ_CAN.c
    ./CAN/Drivers/source/: lpc17xx_clkpwr.c lpc17xx_can.c
    ./CAN/Drivers/include/: lpc17xx_can.h
  group utilities
    ./utilities/: string.cpp string.h
  group security
    ./security/: security.c security.h sha256.c sha256.h aes.c des.c aes.h des.h
  group trng
    ./trng/: adc.h IRQ_adc.c lib_adc.c
  group RIT
    ./RIT/: IRQ_RIT.c lib_RIT.c RIT.h
  group joystick
    ./joystick/: funct_joystick.c joystick.h lib_joystick.c
